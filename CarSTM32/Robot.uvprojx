# Keil uVision project Robot.uvprojx, settings and files
target Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robot_app +hex
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CORE;.\FWlib\inc;.\HARDWARE\Adc;.\HARDWARE\Beep;.\HARDWARE\Common;.\HARDWARE\encoder;.\HARDWARE\Control_app;.\HARDWARE\encoder;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\Motor;.\HARDWARE\OLED;.\HARDWARE\PS2;.\HARDWARE\Servo;.\HARDWARE\Timer;.\SYSTEM\delay;.\SYSTEM\show;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/Adc/: Adc.c
    ./HARDWARE/Beep/: beep.c
    ./HARDWARE/Common/: common.c
    ./HARDWARE/encoder/: encoder.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/PS2/: Ps2.c
    ./HARDWARE/Timer/: timer.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/show/: show.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group USER
    ./USER/: Control.c main.c stm32f10x_it.c system_stm32f10x.c motor.c printf.c AllTasks.h OLED_task.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.0.1
